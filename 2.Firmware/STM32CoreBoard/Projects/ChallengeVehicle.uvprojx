# Keil uVision project ChallengeVehicle.uvprojx, settings and files
target ChallengeVegicle (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ChallengeVehicle
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Projects;..\Hardware;..\Library\stm32f10x_stdlib\core;..\Library\stm32f10x_stdlib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Hardware
    ../Hardware/: hw_adc.c hw_dma.c hw_key.c hw_led.c hw_oled.c hw_timer.c hw_inf&gray.c hw_rplidar.c hw_usart.c
  group Library
    ../Library/stm32f10x_stdlib/core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../Library/stm32f10x_stdlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Projects
    ./: main.c system.c control.c menu.c
